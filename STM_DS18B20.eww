<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\STM_DS18B20.ewp</path>
    </project>
    <batchBuild />
</workspace>
